# IAR project Project.ewp, settings and files
configuration GD32L235 (ARM, debug)
  General.OGChipSelectEditMenu: GD32L235xB GD GD32L235xB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCDefines: GD32L235
  ICCARM.CCIncludePath2: ..\..\Firmware\CMSIS; ..\..\Utilities; ..; ..\..\Firmware\GD32L23x_standard_peripheral\Include; ..\..\Firmware\CMSIS\GD\GD32L23x\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration GD32L233 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: GD32L233xC GD GD32L233xC
  ICCARM.CCDefines: GD32L233
  group Application
    ../: gd32l23x_it.c main.c systick.c
  group CMSIS
    ../../Firmware/CMSIS/GD/GD32L23x/Source/: system_gd32l23x.c
  group Doc
    ../: readme.txt
  group GD32L23x_EVAL
    ../../Utilities/: gd32l23x_eval.c
  group GD32L23x_Peripherals
    ../../Firmware/GD32L23x_standard_peripheral/Source/: gd32l23x_adc.c gd32l23x_can.c gd32l23x_cau.c gd32l23x_cau_aes.c gd32l23x_cau_des.c gd32l23x_cau_tdes.c gd32l23x_cmp.c gd32l23x_crc.c gd32l23x_ctc.c gd32l23x_dac.c gd32l23x_dbg.c gd32l23x_dma.c gd32l23x_exti.c gd32l23x_fmc.c gd32l23x_fwdgt.c gd32l23x_gpio.c gd32l23x_i2c.c gd32l23x_lptimer.c gd32l23x_lpuart.c gd32l23x_misc.c gd32l23x_pmu.c gd32l23x_rcu.c gd32l23x_rtc.c gd32l23x_slcd.c gd32l23x_spi.c gd32l23x_syscfg.c gd32l23x_timer.c gd32l23x_trng.c gd32l23x_usart.c gd32l23x_vref.c gd32l23x_wwdgt.c
  group Startup
    ../../Firmware/CMSIS/GD/GD32L23x/Source/IAR/: startup_gd32l233xx.s startup_gd32l235xx.s
