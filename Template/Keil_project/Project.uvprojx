# Keil uVision project Project.uvprojx, settings and files
target GD32L233 (6120000::V6.12::.\ARMCLANG)
  device: GD32L233RC GigaDevice
  pack: GigaDevice.GD32L23x_DFP.2.0.1
  cpu: IRAM(0x20000000,0x0008000) IROM(0x08000000,0x0040000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32L233
  c include: ..\;..\..\Firmware\CMSIS\GD\GD32L23x\Include;..\..\Firmware\GD32L23x_standard_peripheral\Include;..\..\Utilities
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../: main.c systick.c gd32l23x_it.c
  group CMSIS
    ../../Firmware/CMSIS/GD/GD32L23x/Source/: system_gd32l23x.c
  group Peripherals
    ../../Firmware/GD32L23x_standard_peripheral/Source/: gd32l23x_dac.c gd32l23x_dma.c gd32l23x_exti.c gd32l23x_gpio.c gd32l23x_misc.c gd32l23x_rcu.c gd32l23x_syscfg.c gd32l23x_usart.c gd32l23x_cau.c gd32l23x_cau_aes.c gd32l23x_cau_des.c gd32l23x_cau_tdes.c gd32l23x_dbg.c gd32l23x_fwdgt.c gd32l23x_rtc.c gd32l23x_vref.c gd32l23x_adc.c gd32l23x_cmp.c gd32l23x_crc.c gd32l23x_fmc.c gd32l23x_i2c.c gd32l23x_lpuart.c gd32l23x_pmu.c gd32l23x_spi.c gd32l23x_timer.c gd32l23x_trng.c gd32l23x_wwdgt.c gd32l23x_ctc.c gd32l23x_lptimer.c gd32l23x_slcd.c gd32l23x_can.c
  group Startup
    ../../Firmware/CMSIS/GD/GD32L23x/Source/ARM/: startup_gd32l235xx.s startup_gd32l233xx.s
  group Utilities
    ../../Utilities/: gd32l23x_eval.c
  group Doc
    ../: readme.txt
  group HardWare
    ./HardWare/: i2c_led.c
  group SHT
    ./SHT4X-5.3/: sensirion_common.c sensirion_hw_i2c_implementation.c sht_git_version.c sht4x.c sht4x_example_usage.c
  group SoftWare
    ./SoftWare/: core_task.c useBaseTimer.c
  group HK25Qx
    ./HardWare/: gd25qxx.c
target GD32L235 (6180000::V6.18::ARMCLANG)
  device: GD32L235CB GigaDevice
  pack: GigaDevice.GD32L23x_DFP.2.0.1
  cpu: IRAM(0x20000000,0x0006000) IROM(0x08000000,0x0020000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32L235
  c include: ..\;..\..\Firmware\CMSIS\GD\GD32L23x\Include;..\..\Firmware\GD32L23x_standard_peripheral\Include;..\..\Utilities;.\inc;.\SHT4X-5.3;.\SoftWare
  library: MicroLIB
  memory RVCT4: ROM 0x8002c00 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x6000
software components: CMSIS:CORE 5.6.0
