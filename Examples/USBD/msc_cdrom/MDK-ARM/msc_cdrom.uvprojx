# Keil uVision project msc_cdrom.uvprojx, settings and files
target GD32L233 (6130001::V6.13.1::.\ARMCLANG)
  device: GD32L233RC GigaDevice
  pack: GigaDevice.GD32L23x_DFP.1.1.7
  cpu: IRAM(0x20000000,0x0008000) IROM(0x08000000,0x0040000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: msc_cdrom +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: GD32L233
  c include: ..\inc;..\..\..\..\Firmware\CMSIS\GD\GD32L23x\Include;..\..\..\..\Firmware\GD32L23x_standard_peripheral\Include;..\..\..\..\Firmware\GD32L23x_usbd_library\usbd\Include;..\..\..\..\Firmware\GD32L23x_usbd_library\device\Include;..\..\..\..\Firmware\GD32L23x_usbd_library\class\device\msc\Include;..\..\..\..\Utilities
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../src/: main.c gd32l23x_it.c gd32l23x_usbd_hw.c internal_flash_if.c flash_data.c msc_mem.c
  group CMSIS
    ../src/: system_gd32l23x.c
  group GD32L23x_Peripherals
    ../../../../Firmware/GD32L23x_standard_peripheral/Source/: gd32l23x_exti.c gd32l23x_fmc.c gd32l23x_gpio.c gd32l23x_i2c.c gd32l23x_misc.c gd32l23x_pmu.c gd32l23x_rcu.c gd32l23x_syscfg.c gd32l23x_timer.c gd32l23x_usart.c
  group GD32L23x_EVAL
    ../../../../Utilities/: gd32l23x_eval.c
  group USBD_Drivers
    ../../../../Firmware/GD32L23x_usbd_library/usbd/Source/: usbd_lld_core.c usbd_lld_int.c
  group USBD_Device
    ../../../../Firmware/GD32L23x_usbd_library/device/Source/: usbd_core.c usbd_enum.c usbd_pwr.c usbd_transc.c
  group USBD_Class
    ../../../../Firmware/GD32L23x_usbd_library/class/device/msc/Source/: usbd_msc_bbb.c usbd_msc_core.c usbd_msc_scsi.c
  group Startup
    ../../../../Firmware/CMSIS/GD/GD32L23x/Source/ARM/: startup_gd32l233xx.s startup_gd32l235xx.s
  group Doc
    ../: readme.txt
target GD32L235 (6130001::V6.13.1::.\ARMCLANG)
  device: GD32L235RB GigaDevice
  pack: GigaDevice.GD32L23x_DFP.1.1.7
  cpu: IRAM(0x20000000,0x0008000) IROM(0x08000000,0x0020000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: msc_cdrom +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: GD32L235
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
software components: CMSIS:CORE 5.3.0
