# IAR project hid_printer.ewp, settings and files
configuration GD32L233 (ARM, debug)
  General.OGChipSelectEditMenu: GD32L233xC GD GD32L233xC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCDefines: GD32L233
  ICCARM.CCIncludePath2: ..\..\..\..\Firmware\CMSIS; ..\..\..\..\Utilities; ..\..\..\..\Firmware\GD32L23x_standard_peripheral\Include; ..\..\..\..\Firmware\CMSIS\GD\GD32L23x\Include; ..\inc; ..\..\..\..\Firmware\GD32L23x_usbd_library\usbd\Include; ..\..\..\..\Firmware\GD32L23x_usbd_library\device\Include; ..\..\..\..\Firmware\GD32L23x_usbd_library\class\device\hid\Include; ..\..\..\..\Firmware\GD32L23x_usbd_library\class\device\printer\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: hid_printer.out
configuration GD32L235 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: GD32L235xB GD GD32L235xB
  ICCARM.CCDefines: GD32L235
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../src/: gd32l23x_it.c gd32l23x_usbd_hw.c hid_printer_wrapper.c main.c
  group CMSIS
    ../src/: system_gd32l23x.c
  group Doc
    ../: readme.txt
  group GD32L23x_EVAL
    ../../../../Utilities/: gd32l23x_eval.c
  group GD32L23x_Peripherals
    ../../../../Firmware/GD32L23x_standard_peripheral/Source/: gd32l23x_dma.c gd32l23x_exti.c gd32l23x_gpio.c gd32l23x_misc.c gd32l23x_pmu.c gd32l23x_rcu.c gd32l23x_spi.c gd32l23x_syscfg.c gd32l23x_usart.c
  group Startup
    ../../../../Firmware/CMSIS/GD/GD32L23x/Source/IAR/: startup_gd32l233xx.s startup_gd32l235xx.s
  group USBD_Class
    ../../../../Firmware/GD32L23x_usbd_library/class/device/hid/Source/: custom_hid_core.c
    ../../../../Firmware/GD32L23x_usbd_library/class/device/printer/Source/: printer_core.c
  group USBD_Device
    ../../../../Firmware/GD32L23x_usbd_library/device/Source/: usbd_core.c usbd_enum.c usbd_pwr.c usbd_transc.c
  group USBD_Drivers
    ../../../../Firmware/GD32L23x_usbd_library/usbd/Source/: usbd_lld_core.c usbd_lld_int.c
